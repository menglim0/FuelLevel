# Keil uVision project CANTX_0421.uvproj, settings and files
target Target 1 (ARM-ADS)
  device: ARMCM3 ARM
  pack: ARM.CMSIS.4.1.0
  cpu: CPUTYPE("Cortex-M3") CLOCK(10000000) ESEL ELITTLE
  output: CANTX_0421
  c flags: Optim=1
  group Source Group 1
    ./: STM32F10x.s
