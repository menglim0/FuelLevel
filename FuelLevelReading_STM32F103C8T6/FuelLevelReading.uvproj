# Keil uVision project FuelLevelReading.uvproj, settings and files
target DebugInFlash (5060528::V5.06 update 5 (build 528)::ARMCC)
  device: STM32F103C8 STMicroelectronics
  cpu: IRAM(0x20000000-0x20004FFF) IROM(0x8000000-0x800FFFF) CLOCK(8000000) CPUTYPE("Cortex-M3")
  output: CAN_RX +hex
  c flags: Optim=1 v6Lang=1 v6LangP=1
  c define: USE_STDPERIPH_DRIVER,STM32F10X_LD
  c include: .\startup;.\driver;.\driver\stm32lib\inc;.\user;.\driver\api\inc;.\driver\stm32lib\src;.\driver\stm32lib\inc;..\FuelLevelReading_STM32F103C8T6
  asm include: .\startup
  memory RVCT4: ROM 0x8000000 size 0x10000
  memory RVCT9: RAM 0x20000000 size 0x5000
  group startup
    ./startup/: startup.s os_cpu_a.s core_cm3.c sysinit.c
  group driver
    ./driver/stm32lib/src/: misc.c stm32f10x_rcc.c stm32f10x_gpio.c stm32f10x_tim.c stm32f10x_spi.c stm32f10x_i2c.c stm32f10x_rtc.c stm32f10x_usart.c stm32f10x_adc.c stm32f10x_can.c stm32f10x_cec.c stm32f10x_crc.c stm32f10x_dac.c stm32f10x_dma.c stm32f10x_exti.c stm32f10x_flash.c stm32f10x_fsmc.c stm32f10x_iwdg.c stm32f10x_pwr.c stm32f10x_sdio.c stm32f10x_bkp.c stm32f10x_wwdg.c stm32f10x_dbgmcu.c
  group api
    ./driver/api/src/: gpio.c
  group user
    ./user/: main.c usart.c
    ./: interpol.c
